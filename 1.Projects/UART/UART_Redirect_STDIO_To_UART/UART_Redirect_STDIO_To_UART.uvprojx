# Keil uVision project UART_Redirect_STDIO_To_UART.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_Redirect_STDIO_To_UART
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Inc
    ./Inc/: GPIO_driver.h interrupt_controller.h STDIO_Redirect.h UART_driver.h
  group Src
    ./Src/: GPIO_driver.c interrupt_controller.c main.c STDIO_Redirect.c UART_driver.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
